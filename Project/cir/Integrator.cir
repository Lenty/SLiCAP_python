"Integrator"
.lib SLiCAP.lib
* gnetlist -q -g spice-noqsi -o Integrator.net Integrator.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
R1 2 1 {R_i}
C1 1 int {C_i}
*O1 0 1 int 0 AD8610_A0
O1 0 1 int 0 OPA211_A0
V1 2 0 V value=1 dc=0 dcvar=0 noise=0
.param R_i=80.6k C_i=10p A_0=300k

.end
