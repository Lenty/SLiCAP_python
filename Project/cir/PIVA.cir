"PIVA"
* gnetlist -q -g spice-noqsi -o PIVA.net PIVA.sch
* SPICE file generated by spice-noqsi version 20170819
* Send requests or bug reports to jpd@noqsi.com
V1 8 0 V value=1 dc=0 dcvar=0 noise=0
R9 9 13 {R_d}
R8 6 0 {R_a}
R7 9 Out {R_m}
R6 10 6 {R_b}
R5 2 3 {R_led}
R4 5 0 {R_se}
R3 7 9 {R_f}
R2 4 1 {R_vi}
R1 8 7 {R_i}
O3 0 10 11 0 AD8610
O2 0 1 5 2 AD8610
O1 0 7 4 0 AD8610
M1 9 11 6 6 NDD03N80Z
F2 1 0 12 0 5m
F1 0 10 3 12 5m
C_9 13 0 {C_d}
C8 Out 0 {C_p}
C7 10 6 {C_c}
C6 10 0 {C_pin}
C5 2 0 {C_led}
C4 1 0 {2*C_pin}
C3 1 5 {C_f}
C2 7 9 {C_ph}
C1 7 4 {C_i}
.param R_i=80.6k C_i=10p C_ph=1.95p R_f=2M C_pin=22p R_vi=51k C_f=4.7p C_led=80p R_led=25 R_se=300 C_c=3.9p R_b=51k R_a=510 R_m=150 C_d=220p R_d=1k C_p=1n I_D=1m
.end
