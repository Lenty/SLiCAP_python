"PSD noise model"
* gnetlist -q -g spice-noqsi -o PSDnoiseDesign.net PSDnoiseDesign.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.include SLiCAP.lib
C1 1 0 {0.5*C_s}
C2 1 outP {C_i}
C3 2 0 {0.5*C_s}
.param C_i = 37.5p R_PSD = 64k C_s = 20p
R1 1 2 {R_PSD}
C4 2 outN {C_i}
X1 1 0 outP 0 N_noise sv={S_v} si={S_i}
X2 2 0 outN 0 N_noise sv={S_v} si={S_i}
I1 1 2 I value=0 dc=0 dcvar=0 noise={4*k*T/R_PSD}
.end
