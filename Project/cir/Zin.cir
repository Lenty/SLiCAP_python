"Circuit for Zin"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o Zin.net Zin.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
N1 outP 0 input 1
R4 1 outP {R_2}
R3 1 0 {R_3}
E1 outN 0 outP 0 -1
R1 input outN {R_1}
I1 0 input I value={I_input} dc=0 dcvar=0 noise=0
.param R_s=50
.end
