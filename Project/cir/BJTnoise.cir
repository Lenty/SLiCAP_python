"BJT noise model verification"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o BJTnoise.net BJTnoise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
V1 1 0 V value=0 dc=0 dcvar=0 noise={4*k_B*T_A*R_s}
R1 1 2 {R_s}
X1 2 0 out Q_noise IC={I_C} VCE={V_CE}
.param V_CE=10 R_s=200
.end
