"Circuit for noise"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o Noise.net Noise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.param R_s=50
R2 2 1 {R_s}
N1 outP 0 1 3
R4 3 outP {R_2}
R3 3 0 {R_3}
E1 outN 0 outP 0 -1
R1 1 outN {R_1}
V1 2 0 V value=0 dc=0 dcvar=0 noise={4*k_B*T_A*R_s}
I1 1 outN I value=0 dc=0 dcvar=0 noise={4*k_B*T_A/R_1}
I2 0 3 I value=0 dc=0 dcvar=0 noise={4*k_B*T_A/R_3}
I3 3 outP I value=0 dc=0 dcvar=0 noise={4*k_B*T_A/R_2}
.end
