"CS stage capacitive voltage noise"
* gnetlist -q -g spice-noqsi -o CScapNoiseV.net CScapNoiseV.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.INCLUDE SLiCAP.lib
X1 1 0 out NM18_noise ID={ID} W={W} L={L} IG={IG}
V1 2 0 V value=0 dc=0 dcvar=0 noise=0
.param C_s=0.1p W=66u L=180n ID=7.44m IG=0
C1 2 1 {C_s}
.end
