"CS stage capacitive current noise"
* gnetlist -q -g spice-noqsi -o CScapNoiseI.net CScapNoiseI.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.INCLUDE SLiCAP.lib
X1 1 0 out NM18_noise ID={ID} W={W} L={L} IG={IG}
.param C_s=0.1p W=57.4u L=180n ID=6.47m IG=0
C1 0 1 {C_s}
I1 1 0 I value=0 dc=0 dcvar=0 noise=0
.end
