"N18noise"
* gnetlist -q -g spice-noqsi -o N18noise.net N18noise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.INCLUDE SLiCAP.lib
X1 1 0 out NM18_noise ID={ID} W={W} L={L} IG=0
V1 1 0 V value=0 dc=0 dcvar=0 noise=0
.param W=220n L={W} ID=1u
.end
