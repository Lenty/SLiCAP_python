"P18noise"
* gnetlist -q -g spice-noqsi -o P18noise.net P18noise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.INCLUDE SLiCAP.lib
X1 1 0 out PM18_noise ID={ID} W={W} L={L} IG={IG}
V1 1 0 V value=0 dc=0 dcvar=0 noise=0
.param ID=10u IG=0 W=220n L=180n
.end
