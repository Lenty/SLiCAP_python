"OutputStage"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o OutputStage.net OutputStage.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
.INCLUDE /mnt/DATA/SLiCAP/Examples/PIVA/PIVA.lib
R3 1 0 {R_a}
R2 2 1 {R_b}
C3 2 1 {C_c}
C2 2 0 {C_pin}
O1 0 2 3 0 AD8610_A0
M1 4 3 1 1 NDD03N80Z
.param C_pin=22p C_c=3.9p R_b=51k R_a=510 A_0=300k I_D=1m

I1 5 0 I value=1 dc=0 dcvar=0 noise=0
V1 4 0 V value=0 dc=0 dcvar=0 noise=0
F1 0 2 5 0 5m
.end
