"CMOS18 NMOS noise test"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o MN18_noise.net MN18_noise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
X1 1 0 out NM18_noise ID={I_D} W={W} L={L} IG=0
R1 2 1 {R_s}
V1 2 0 V value=0 dc=0 dcvar=0 noise={4*k_B*T_A*R_s}
.param I_D=1m W=2.5u L=180n R_s=50k
.end
