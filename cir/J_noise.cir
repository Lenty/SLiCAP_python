"JFET, MOS noise test"
.include SLiCAP.lib
* gnetlist -q -g spice-noqsi -o J_noise.net J_noise.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
R1 2 1 {R_s}
V1 2 0 V value=0 dc=0 dcvar=0 noise={4*k_B*T_A*R_s}
.param R_s=5k I_D=1m
X1 1 0 out J_noise ID={I_D} IG=0
.end
