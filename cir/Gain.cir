"Circuit for gain"
.include circuits/SLiCAP.lib
* gnetlist -q -g spice-noqsi -o Gain.net Gain.sch
* SPICE file generated by spice-noqsi version 20130710
* Send requests or bug reports to jpd@noqsi.com
R2 2 1 {R_s}
N1 outP 0 1 3
R4 3 outP {R_2}
R3 3 0 {R_3}
E1 outN 0 outP 0 -1
R1 1 outN {R_1}
V1 2 0 V value={V_s} dc=0 dcvar=0 noise=0
.param R_s=50
.end
